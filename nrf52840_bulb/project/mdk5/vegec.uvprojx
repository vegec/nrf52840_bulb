# Keil uVision project vegec.uvprojx, settings and files
target nrf52840_qfaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: vegec +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10056 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\config;..\..\components\boards;..\..\modules\nrfx;..\..\modules\nrfx\hal;..\..\integration\nrfx;..\..\components\drivers_nrf\nrf_soc_nosd;..\..\components\libraries\delay;..\..\components\libraries\util;..\..\components\libraries\strerror;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\balloc;..\..\components\libraries\memobj;..\..\modules\nrfx\drivers\include;..\..\integration\nrfx\legacy;..\..\components\libraries\uart;..\..\components\libraries\fifo;..\..\app\w5500;..\..\app\esp8266;..\..\app\tm1914a
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../../app/: main.c
    ../config/: sdk_config.h
    ../../app/w5500/: w5500.c
    ../../app/esp8266/: esp8266.c
    ../../app/tm1914a/: tm1914.c
  group Board Definition
    ../../components/boards/: boards.c
  group nRF_Libraries
    ../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c app_error_handler_keil.c app_error_weak.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../components/libraries/fifo/: app_fifo.c
  group nRF_Drivers
    ../../integration/nrfx/legacy/: nrf_drv_uart.c nrf_drv_spi.c
    ../../modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c nrfx_gpiote.c nrfx_spim.c nrfx_spi.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.17.0
